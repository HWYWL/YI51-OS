# Keil uVision project SCH51_App.uvproj, settings and files
target SCH51_App (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: YI51_App_OS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SCH51;..\task
  group user
    ./: Main.c
  group SCH51
    ../SCH51/: Sch51.c T0_UART_INIT.C
  group task
    ../task/: task.c
